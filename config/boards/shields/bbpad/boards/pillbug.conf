## config/boards/shields/bbpad/boards/pillbug.conf
```kconfig
# Currently necessary until merged into main ZMK repo

# Use pinctrl
CONFIG_PINCTRL=y
```
